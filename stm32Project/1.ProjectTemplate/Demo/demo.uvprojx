# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Template\User;..\Template\Libraries\CMSIS\CM3\CoreSupport;..\Template\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Template\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Template\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Template/User/: main.c stm32f10x_it.c
  group Cmsis
    ../Template/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Template/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Template/Startup/: startup_stm32f10x_hd.s
  group STDriver
    ../Template/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
